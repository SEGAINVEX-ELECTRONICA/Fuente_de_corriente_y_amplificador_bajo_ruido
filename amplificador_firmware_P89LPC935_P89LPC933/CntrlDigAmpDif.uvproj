# Keil uVision project CntrlDigAmpDif.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89LPC935 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM (0-0x1FF) CLOCK(12000000) MODP2
  output: CntrlDigAmpDif +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: START900.A51 ControlDigitalAmpDifP89LPC935.C
