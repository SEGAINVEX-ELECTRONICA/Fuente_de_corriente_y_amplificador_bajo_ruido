# Keil uVision project ControlDigital.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89LPC933 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFF) CLOCK(12000000) MODP2
  output: ControlDigital933 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: START900.A51 ControlFuenteCorriente.C
